v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 0 -60 0 0 {lab=gnd}
N 0 -120 80 -120 {lab=gnd}
N 80 -120 80 -60 {lab=gnd}
C {sg13g2_pr/cap_cmim.sym} 0 -90 0 0 {name=C3
model=cap_cmim
w=5.0e-6
l=5.0e-6
m=1
spiceprefix=X}
C {lab_pin.sym} 0 0 0 0 {name=p24 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 80 -60 0 0 {name=p25 sig_type=std_logic lab=gnd}
